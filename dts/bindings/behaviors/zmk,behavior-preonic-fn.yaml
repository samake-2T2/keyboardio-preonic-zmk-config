## dts/bindings/behaviors/zmk,behavior-preonic-fn.yaml
```yaml
description: Keyboardio Preonic custom functions behavior

compatible: "zmk,behavior-preonic-fn"

include: one_param.yaml
```
